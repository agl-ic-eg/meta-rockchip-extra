# NanoPC-T6 support

SRC_URI:nanopct6 = " \
    git://github.com/friendlyarm/kernel-rockchip.git;protocol=https;nobranch=1;branch=nanopi6-v6.1.y; \
"
SRCREV:nanopct6 = "06f441a65bf4d9dc1d2361fa3cbd182584ea590f"
